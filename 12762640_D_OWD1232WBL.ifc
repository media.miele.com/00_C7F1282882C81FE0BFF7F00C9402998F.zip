Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 2e807cc0-eeeb-455c-a2fb-a6ab4ff37d30, NumberOfSaves: 1]
File name: 0001
Time: 2026-01-29T12:25:47+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12762640_D_OWD1232WBL:331B3DWW_D_12762640_OWD1232WBL, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 331B3DWW_D_12762640_OWD1232WBL; sets with these values: 2
